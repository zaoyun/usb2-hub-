# Repository zaoyun/usb2-hub-

## KiCad design usb2 hub.kicad_pcb

Parts:
C1, C8: 12pf; C_0402_1005Metric
C2, C3: 10uf; C_0402_1005Metric
C4, C5, C6, C7: 1uf; C_0402_1005Metric
D1: LED; LED_0402_1005Metric
F1, F2, F3, F4, F5: Fuse; Fuse_0603_1608Metric
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_Palconn_UTC16-G
J2, J3, J4, J5: Conn_01x04_Female; PinHeader_1x04_P1.27mm_Vertical
J6, J7, J8, J9: CAN; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal
J10, J11, J12, J13, J14, J15, J16, J17: Conn_01x03_Male; JST_GH_SM03B-GHS-TB_1x03-1MP_P1.25mm_Horizontal
J18, J19, J20, J21: Conn_01x03_Male; PinHeader_1x03_P2.54mm_Horizontal
J22, J23, J24, J25: Conn_01x06_Male; PinHeader_1x06_P1.27mm_Vertical
R1: 2.7k; R_0402_1005Metric
R2: 1.5K; R_0402_1005Metric
R3, R4: 510R; R_0402_1005Metric
U1: FE8.1; SSOP-16_4.4x5.2mm_P0.65mm
Y1: 12MHZ; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm

Connections:
+3.3V: C2.1, R2.1, U1.13 (VD33F)
+5V: C3.1, C4.2, C5.2, C6.2, C7.2, F1.2, F2.2, F3.2, F4.2, F5.2, J18.2, J19.2, J20.2, J21.2, J22.6, J23.6, J24.6, J25.6, R3.2, U1.12 (VDD5)
/CAN1+: J6.2, J10.2, J25.1
/CAN1-: J6.1, J10.3, J25.2
/CAN2+: J7.2, J12.2, J24.1
/CAN2-: J7.1, J12.3, J24.2
/CAN3+: J8.2, J13.2, J22.1
/CAN3-: J8.1, J13.3, J22.2
/CAN4+: J9.2, J11.2, J23.1
/CAN4-: J9.1, J11.3, J23.2
/DBUS1_RX: J18.1, J25.5
/DBUS2_RX: J19.1, J24.5
/DBUS3_RX: J20.1, J22.5
/DBUS4_RX: J21.1, J23.5
/UART1_RX: J17.2, J25.3
/UART1_TX: J17.3, J25.4
/UART2_RX: J14.2, J24.3
/UART2_TX: J14.3, J24.4
/UART3_RX: J15.2, J22.3
/UART3_TX: J15.3, J22.4
/UART4_RX: J16.2, J23.3
/UART4_TX: J16.3, J23.4
/USB1+: J2.3, U1.8 (DM1+)
/USB1-: J2.2, U1.7 (DM1-)
/USB2+: J3.3, U1.6 (DM2+)
/USB2-: J3.2, U1.5 (DM2-)
/USB3+: J4.3, U1.4 (DM3+)
/USB3-: J4.2, U1.3 (DM3-)
/USB4+: J5.3, U1.2 (DM4+)
/USB4-: J5.2, U1.1 (DM4-)
/USB+: J1.A6 (D+), J1.B6 (D+), R2.2, U1.11 (DPU+)
/USB-: J1.A7 (D-), J1.B7 (D-), U1.10 (DMU-)
GND: C2.2, C3.2, C4.1, C5.1, C6.1, C7.1, D1.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.4, J3.4, J4.4, J5.4, J10.1, J11.1, J12.1, J13.1, J14.1, J15.1, J16.1, J17.1, J18.3, J19.3, J20.3, J21.3, R1.2, R4.2, U1.14 (VSS), Y1.2, Y1.4
unnamed: C1.1, U1.16 (XOUT)
unnamed: C1.2, Y1.1
unnamed: C8.1, U1.15 (XIN)
unnamed: C8.2, Y1.3
unnamed: D1.2 (A), R3.1
unnamed: F1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
unnamed: J1.A5 (CC1), J1.B5 (CC2), R4.1
unnamed: R1.1, U1.9 (REXT)
VBUS: F2.1, F3.1, F4.1, F5.1, J2.1, J3.1, J4.1, J5.1

Notes on the sheet:
主控芯片
DBUS
驱动引脚
type-c输入
CAN
1.27排针输出
SERIAL

Board: 2 copper layers, 55.0 x 45.8 mm, 45 parts (14 on the bottom side), 42 nets.
